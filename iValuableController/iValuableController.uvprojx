# Keil uVision project iValuableController.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F427ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: iValuableController +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: HSE_VALUE=25000000
  c misc: --gnu
  c include: .\bson;.\
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT6: RAM 0x60000000 size 0x800000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\iValuableController.sct
  group Source Group 1
    ./: main.cpp CanDevice.cpp CanEx.cpp System.c Retarget.cpp
  group Driver
    ./: Driver_CAN.c CAN_STM32F40x.c
  group BSON
    ./bson/: BsonBinary.cpp BsonCString.cpp BsonDocument.cpp BsonString.cpp Element.cpp Guid.cpp MemStream.cpp TypeInfoBase.cpp
software components: CMSIS:CORE 3.40.0, CMSIS:RTOS:Keil RTX 4.75.0, Network:CORE 6.2.0, Network:Interface:ETH 6.2.0, Network:Socket:TCP 6.2.0, Network:Socket:UDP 6.2.0, CMSIS Driver:Ethernet MAC 2.01, CMSIS Driver:Ethernet PHY:LAN8720 6.00, CMSIS Driver:USART 2.01, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:CAN 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:RNG 1.1.0, Device:STM32Cube HAL:SDRAM 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:Startup 2.1.0
